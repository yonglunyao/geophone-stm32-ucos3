# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Malloc;.\APP\flash;.\APP\CH376;.\FATFS\;.\FATFS\FATFS_APP;.\APP\sd;.\APP\exti;.\APP\time;.\APP\SIM7600;.\APP\iic;.\APP\spi;.\APP\GPS;.\APP\iwdg;.\Public;.\APP\ADS1256;.\APP\dma;.\APP\exti;.\APP\time;.\APP\pwm;.\UCOSIII\uC-BSP;.\UCOSIII\uC-CONFIG;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\uCOS-III;.\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_iwdg.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_sdio.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group Public
    ./Public/: system.c usart.c delay.c
  group APP
    ./APP/GPS/: gps.c
    ./APP/spi/: spi.c
    ./APP/time/: time.c
    ./APP/exti/: exti.c
    ./APP/sd/: sdio_sdcard.c
    ./APP/flash/: flash.c
    ./APP/dma/: dma.c
    ./APP/iic/: iic.c
    ./APP/SIM7600/: sim7600.c
    ./APP/iwdg/: iwdg.c
    ./APP/ADS1256/: bsp_ads1256.c
    ./APP/CH376/: CH376.C FILE_SYS.C
  group UCOSIII_CPU
    ./UCOSIII/uC-CPU/: cpu_core.c
    ./UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_BSP
    ./UCOSIII/uC-BSP/: bsp.c
  group UCOSIII_LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CONFIG
    ./UCOSIII/uC-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group FATFS
    ./FATFS/FATFS_APP/: fatfs_app.c
    ./FATFS/: diskio.c ff.c
    ./FATFS/option/: ccsbcs.c
  group Malloc
    ./Malloc/: malloc.c
